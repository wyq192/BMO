# Keil uVision project ESK32-30501.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HT32F52352_64LQFP Holtek
  pack: Holtek.HT32_DFP.1.0.53
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x1FE00) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ESK32-30501
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F52352_SK, USE_HT32F52342_52, USE_MEM_HT32F52352
  c misc: --diag_suppress=111 --diag_suppress=188
  c include: .\HT32F5xxxx_Driver\inc;..\Common\include;..\Source\include;..\Source\portable\RVDS\ARM_CM0;.\CMSIS\Include;.\Config;.\System
  asm define: USE_HT32_CHIP=4, USE_LIBCFG_RAM_SIZE=0x4000
  memory RVCT4: ROM 0x0 size 0x1fe00
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Keil_Specific\ESK32-30501.sct
  link misc: --entry Reset_Handler
  group HT_Library
    ./HT32F5xxxx_Driver/src/: ht32_cm0plus_misc.c ht32f5xxxx_adc.c ht32f5xxxx_bftm.c ht32f5xxxx_ckcu.c ht32f5xxxx_cmp.c ht32f5xxxx_crc.c ht32f5xxxx_ebi.c ht32f5xxxx_exti.c ht32f5xxxx_flash.c ht32f5xxxx_gpio.c ht32f5xxxx_i2c.c ht32f5xxxx_i2s.c ht32f5xxxx_mctm.c ht32f5xxxx_pdma.c ht32f5xxxx_pwrcu.c ht32f5xxxx_rstcu.c ht32f5xxxx_rtc.c ht32f5xxxx_sci.c ht32f5xxxx_spi.c ht32f5xxxx_tm.c ht32f5xxxx_usart.c ht32f5xxxx_usbd.c ht32f5xxxx_wdt.c
  group FreeRTOS_Source
    ../Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../Source/portable/RVDS/ARM_CM0/: port.c portmacro.h
    ../Source/portable/MemMang/: heap_2.c
  group System_Keil
    ./Keil_Specific/: startup_ht32f5xxxx_01.s
  group System
    ./System/: ht32f5xxxx_01_it.c system_ht32f5xxxx_01.c
  group Config
    ./Config/: FreeRTOSConfig.h ht32f5xxxx_conf.h
  group Main
    ./Main/: main.c console.c MFRC522.c console.h MFRC522.h MFRC522_conf.h
