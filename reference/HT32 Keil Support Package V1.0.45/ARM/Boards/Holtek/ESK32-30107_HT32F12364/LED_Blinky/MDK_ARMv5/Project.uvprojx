# Keil uVision project Project.uvprojx, settings and files
target HT32 (ARM-ADS)
  device: HT32F12364 Holtek
  pack: Holtek.HT32_DFP.1.0.18
  cpu: IROM(0x00000000-0x0003FBFF) IRAM(0x20000000-0x2001FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: HT32 +hex
  AfterMake: fromelf --bin -o "!L.bin" "!L"
  c flags: Optim=3 OneElfS=1 wLevel=2
  library: MicroLIB
  link misc: --entry Reset_Handler
  group User
    ../: main.c LED.c
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.1
