# Keil uVision project Project.uvprojx, settings and files
target HT32 (ARM-ADS)
  device: HT32F57352 Holtek
  pack: Holtek.HT32_DFP.1.0.21
  cpu: IROM(0x00000000-0x0001FBFF) IRAM(0x20000000-0x20003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: HT32 +hex
  AfterMake: fromelf --bin -o "!L.bin" "!L"
  c flags: Optim=3 OneElfS=1 wLevel=2
  library: MicroLIB
  link misc: --entry Reset_Handler
  group User
    ../: main.c LED.c
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.1
